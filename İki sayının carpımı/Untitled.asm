#include <P16f877A.inc>
list p=16f877a
ORG 0X00
GOTO BASLA

ORG 0X04
GOTO KESME

BASLA:
CALL AYAR
MOVLW 0X05
MOVWF SAYI1
MOVLW 0X04
MOVWF SAYI2
MOVLW 0X00
MOVWF SAYI3

LOOP:
MOVFW	SAYI1
ADDWF	SAYI3,1
;MOVWF	SAYI3
DECFSZ	SAYI2
GOTO 	LOOP


MOVFW 	SAYI3
MOVWF 	PORTB


GOTO	BITIR

AYAR:
SAYI1 	EQU 0X20
SAYI2 	EQU 0X21
SAYI3 	EQU 0X22
CLRF PORTB
BANKSEL TRISB
CLRF TRISB
BANKSEL PORTB

RETFIE

KESME:

BITIR:
NOP
NOP

END


