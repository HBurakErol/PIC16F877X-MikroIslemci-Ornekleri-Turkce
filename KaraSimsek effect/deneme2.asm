#include <P16f877A.inc>
list p=16f877a
ORG 0X00
GOTO BASLA

ORG 0X04
KESME:


BASLA:
CLRF PORTB
BANKSEL TRISB
CLRF TRISB
BANKSEL PORTB
MOVLW B'00000001'
MOVWF PORTB
GOTO SOLA

SAGA:
RRF PORTB, F
BTFSS PORTB, 0
GOTO SAGA
GOTO SOLA

SOLA:
RLF PORTB, F
BTFSS PORTB, 7
GOTO SOLA
GOTO SAGA
end
